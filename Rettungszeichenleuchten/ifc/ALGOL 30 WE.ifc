Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Projektnummer
Time: 2021-02-15T11:39:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternativ-UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 15 11:39:00 2021 * Host: NB-MAYNICKE-W10 * Database: C:\Users\DMAYNI~1.CAD\AppData\Local\Temp\{859A28C9-488C-4E1C-8A29-14F6F9825AF5}\ifc * Database version: 5507 * Database creation date: Mon Feb 15 11:38:59 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 15 11:38:59 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 15 11:38:59 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Grafiken(Type) - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes

# IfcFlowTerminal: ALGOL 30 WE, GAZ ALGOL 30:ALGOL 30 WE:535021
In: Ebene 0
Type - Material: Weiss leuchtend, Gruen leuchtend, Stahl weiss
Type - Abmessungen - Breite: 0.355 m; Höhe: 0.205 m; Tiefe: 0.071 m
Type - Elektro - Lampe: LED
Type - Elektro - Lasten - Scheinlast: 7 W
Type - ID-Daten - Bauelement: Rettungszeichenleuchte; Beschreibung: vielseitig einsetzbare Rettungszeichenleuchte im zeitlosen Design; Hersteller: GAZ Notstromsysteme GmbH; Modell: ALGOL 30 WA; OmniClass-Nummer: 23.80.70.17.11; OmniClass-Titel: Emergency Signs; Typenkommentare: Wandeinbau; Typname: ALGOL 30 WE; URL: https://gaz.de/
Type - Materialien und Oberflächen - Gehäusefarbe: weiß RAL 9016, Sonderfarben verfügbar; Werkstoff, Gehäuse Notbeleuchtung: Stahl, beschichtet, Rettungszeichenträger Kunststoff
Type - Modelleigenschaften - _Einzelbatterie: no; _Zentralbatterie: yes; Anordnung Rettungszeichen: einseitig; Ausbildung Leuchtmittel: LED; Bauteil, Not-/Sicherheitsbeleuchtung: Rettungszeichenleuchte; Bemessungsbetriebsdauer h Notlichtstrahler: -; Bemessungsbetriebsspannung V: 230 AC/220 DC (+/- 20%); Betriebsart Notbeleuchtung: Dauerschaltung; Gegenstand Beleuchtung: Flucht-/Rettungsweg; Leuchte Bauweise: im Kompaktgehäuse, ballwurfsicher; Max.-Erkennungsweite m: 30; Montage Notleuchte: Wandeinbau; Produktinformationen: https://gaz.de/g-light/rettungszeichenleuchten/; Schutzart: IP40; Schutzklasse elektrische Betriebsmittel: I; Spannung: 230 V; Umgebungstemperatur Grad C: -10 bis +40
Type - Sonstige - Kategorie: Leuchten; Familienname: GAZ ALGOL 30
Type - Vollständige Legende - B_Abzug Breite: 0.315 m; B_Abzug Höhe: 0.195 m; B_Abzug Tiefe: 0.063 m; B_Abzug Versatz oben: 0.005 m; B_Abzug Versatz vorn: 0.008 m; B_Anschuss Versatz oben: 0.1025 m; B_Blende hinten: no; B_Blende vorn: yes; B_B MK: yes; B_Einfüge Versatz von oben: 0 m; B_Einfüge Versatz von vorn: 0.008 m; B_MK Breite: 0.31 m; B_MK Versatz hinten: 0.001 m; B_MK Versatz oben: 0.005 m; B_MK Versatz unten: 0.005 m; B_MK Versatz vorn: 0.008 m; B_Montage: 6; B_Montage DA: no; B_Montage DA Seil: no; B_Montage DE: no; B_Montage DE Seil: no; B_Montage WA: no; B_Montage WE: yes; B_Pikto Extr h g: 0 m; B_Pikto Extr h Logo: 0 m; B_Pikto Extr h w: 0 m; B_Pikto Extrusion green: -0.072 m; B_Pikto Extrusion white: -0.073 m; B_Pikto Extr v g: 0.001 m; B_Pikto Extr v Logo: 0.002 m; B_Pikto Extr v w: 0.002 m; B_Pikto Mitte von unten: 0.1025 m
Pset_ManufacturerTypeInformation - Manufacturer: GAZ Notstromsysteme GmbH
Pset_DistributionFlowElementCommon - Reference: ALGOL 30 WE
Abhängigkeiten - Basisbauteil: Ebene : Ebene 0; Ebene: Ebene: Ebene 0; Grundriss Symbol: no; Montage/-Deckenhöhe: 0 m; Piktogramm: 1; Versatz: 0 m
Abmessungen - Fläche: 0.24235 m2; Volumen: 0.0043301 m3
Elektro - Beleuchtung - Wirkungsgrad berechnen: no
Elektro - Stromkreise - Elektrische Daten: 230 V/1-7 VA
ID-Daten - Kennzeichen: 33
Phasen - Phase erstellt: Phase 1
Sonstige - Familie: GAZ ALGOL 30: ALGOL 30 WE; Familie und Typ: GAZ ALGOL 30: ALGOL 30 WE; Typ: GAZ ALGOL 30: ALGOL 30 WE; Typ-ID: GAZ ALGOL 30: ALGOL 30 WE
Vollständige Legende - B_Pikto Fi Li: yes; B_Pikto Fi Re: no; B_Pikto Pfeil Winkel: 0 deg; B_Symbol Links: no; B_Symbol Oben: no; B_Symbol Rechts: yes; B_Symbol Unten: no
